# Keil uVision project Project.uvprojx, settings and files
target STM32746G_DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32746G_DISCOVERY
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCOVERY
  c misc: --C99
  c include: ../Inc;../Src;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32746G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: err.c netbuf.c api_lib.c tcpip.c netdb.c netifapi.c sockets.c api_msg.c
  group Drivers/BSP/STM32746G_Discovery
    ../../../../../../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_sdram.c stm32746g_discovery_lcd.c stm32746g_discovery_ts.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_ll_fmc.c stm32f7xx_hal_flash.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal_uart.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr_ex.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: timeouts.c udp.c ip.c dns.c def.c raw.c stats.c memp.c init.c sys.c pbuf.c netif.c tcp_out.c tcp.c mem.c inet_chksum.c tcp_in.c
  group Middlewares/LwIP/apps/httpd
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/httpd/: httpd.c fs.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c croutine.c queue.c tasks.c list.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c icmp.c autoip.c ip4.c ip4_addr.c ip4_frag.c igmp.c dhcp.c
  group Application/User
    ../Src/: main.c httpserver-netconn.c ethernetif.c stm32f7xx_hal_timebase_tim.c app_ethernet.c stm32f7xx_it.c
    ./: x10.c touchscreen.c
    ../Inc/: touchscreen.h
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ov9655/: ov9655.c
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
software components: CMSIS:CORE 4.3.0
